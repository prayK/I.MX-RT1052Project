# IAR project NewProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: E:\Code\MCU\RT1052NewProject\App\inc; E:\Code\MCU\RT1052NewProject\App\src; E:\Code\MCU\RT1052NewProject\Board\inc; E:\Code\MCU\RT1052NewProject\Board\src; E:\Code\MCU\RT1052NewProject\Chip\inc\IAR; E:\Code\MCU\RT1052NewProject\Chip\inc\RT1052; E:\Code\MCU\RT1052NewProject\Chip\src\IAR; E:\Code\MCU\RT1052NewProject\Chip\inc; E:\Code\MCU\RT1052NewProject\Chip\src; E:\Code\MCU\RT1052NewProject\CMSIS
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NewProject.srec
  ILINK.IlinkOutputFile: NewProject.out
  ILINK.IlinkIcfFile: E:\Code\MCU\RT1052NewProject\Prj\IAR\ConfigFiles\MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/src
    ../../App/src/: main.c
  group Chip/inc/IAR
    ../../Chip/inc/IAR/: system_MIMXRT1052.h
  group Chip/inc/RT1052
    ../../Chip/inc/RT1052/: MIMXRT1052.h
  group Chip/src/IAR
    ../../Chip/src/IAR/: startup_MIMXRT1052.s system_MIMXRT1052.c
  group CMSIS
    ../../CMSIS/: cmsis_compiler.h cmsis_version.h core_cm7.h
